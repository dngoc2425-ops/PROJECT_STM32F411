# Keil uVision project STM32F411.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: STM32F411
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: CLOCK.c CLOCK.h main.c GPIO.c GPIO.h ADC.c ADC.h DMA.c DMA.h ACTUATOR.c ACTUATOR.h SENSOR.c SENSORS.h SPI.c SPI.h NVIC.c NVIC.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
